## build/ADC_prototype/Kconfig/boards/Kconfig.nrf52dk
```kconfig
# Load board Kconfig descriptions.
osource "C:/ncs/v3.2.1/zephyr/boards/nordic/nrf52dk/Kconfig.nrf52dk"
```
